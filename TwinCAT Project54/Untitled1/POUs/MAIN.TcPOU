PROGRAM MAIN
VAR

END_VAR

TCPServer();

END_PROGRAM
